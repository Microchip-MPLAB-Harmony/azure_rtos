# IAR project basic_threadx_sam_9x60_ek_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: TX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_9x60_ek_iar; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\src\config\sam_9x60_ek_iar\threadx_config; ..\src\third_party\rtos\threadx\common\inc; ..\src\third_party\rtos\threadx\ports\arm9\iar\inc; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\config\sam_9x60_ek_iar\threadx_config; ..\src\third_party\rtos\threadx\common\inc; ..\src\third_party\rtos\threadx\ports\arm9\iar\inc; .
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TX_INCLUDE_USER_DEFINE_FILE; NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h user.h configuration.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pit64b
    ../src/config/sam_9x60_ek_iar/peripheral/pit64b/: plib_pit64b.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/threadx_config
    ../src/config/sam_9x60_ek_iar/threadx_config/: tx_user.h sam9x6_tx_timer.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/osal
    ../src/config/sam_9x60_ek_iar/osal/: osal.h osal_definitions.h osal_threadx.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Header Files/threadx/common/inc
    ../src/third_party/rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h
  group Harmony3/Header Files/threadx/ports/arm9/iar/inc
    ../src/third_party/rtos/threadx/ports/arm9/iar/inc/: tx_port.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: initialization.c interrupts.c cstartup.s vectortrap.s tasks.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/stdio
    ../src/config/sam_9x60_ek_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pit64b
    ../src/config/sam_9x60_ek_iar/peripheral/pit64b/: plib_pit64b.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/threadx_config
    ../src/config/sam_9x60_ek_iar/threadx_config/: sam9x6_tx_port.s sam9x6_tx_timer.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/osal
    ../src/config/sam_9x60_ek_iar/osal/: osal_threadx.c
  group Harmony3/Source Files/threadx/common/src
    ../src/third_party/rtos/threadx/common/src/: txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_timeout.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_wait_abort.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_time_get.c tx_time_set.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c
  group Harmony3/Source Files/threadx/ports/arm9/iar/src
    ../src/third_party/rtos/threadx/ports/arm9/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_fiq_context_restore.s tx_thread_fiq_context_save.s tx_thread_fiq_nesting_end.s tx_thread_fiq_nesting_start.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_irq_nesting_end.s tx_thread_irq_nesting_start.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_thread_vectored_context_save.s tx_timer_interrupt.s tx_initialize_low_level.s
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_iar/: ddram.icf
